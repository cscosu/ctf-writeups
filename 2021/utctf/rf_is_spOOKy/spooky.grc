options:
  parameters:
    generate_options: qt_gui
    id: spooky
    output_language: python
    title: spooky
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '180000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '15'
    gain: '1'
    high_cutoff_freq: '46500'
    low_cutoff_freq: '44500'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /CHANGME/cut.u8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /CHANGEME/cut.u8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '160'
    init: '0'
    low: '150'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: Complex uint8 Frequency Sink
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Complex uint8 Time Sink (after threshold)
    size: '18000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Real uint8 Time Sink
    size: '18000'
    srate: samp_rate
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_char_to_float_0, '0', blocks_throttle_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
